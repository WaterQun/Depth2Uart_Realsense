# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\ENCODER;..\HARDWARE\LED;..\HARDWARE\Motor;..\HARDWARE\RCC;..\HARDWARE\SYSTICK;..\HARDWARE\TIME;..\HARDWARE\NVIC;..\HARDWARE\USART;..\HARDWARE\mbotlinux;..\HARDWARE\OLED;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/RCC/: bsp_rccclkconfig.c
    ../HARDWARE/SYSTICK/: bsp_systick.c
    ../HARDWARE/TIME/: tim1.c tim3.c
    ../HARDWARE/USART/: usart1.c usart2.c usart3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/NVIC/: nvic.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
  group README
    ../: readme.txt
